# Keil uVision project GC-Net-STM32F0xx.uvproj, settings and files
target GcNetSTM32F030C8 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: GC-Net-STM32F0xx +hex
  AfterMake: fromelf.exe --bin -o ./obj/GC-Net-STM32F0xx.bin ./obj/GC-Net-STM32F0xx.axf
  c flags: Optim=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER HSE_VALUE=10000000
  c misc: --c99
  c include: .\GC-Net\inc;.\lib\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\lib\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\lib\Libraries\CMSIS\Include;..\GC-Net-STM32F0xx;.
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7c00
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./GC-Net/src/: globaldata.c network.c plcm_uart.c sm2200serialspi.c transmit.c gc2200.c plcm.c uart.c
    ./: platform.c platformIRAM.c
  group lib
    ./lib/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group CMSIS
    ./lib/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
    ./lib/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
